v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -70 -0 -40 -0 {lab=#net1}
N 90 -0 120 -0 {lab=#net2}
N 250 -0 280 -0 {lab=#net3}
N 410 0 450 -0 {lab=#net4}
N 580 0 620 -0 {lab=#net5}
N 750 0 790 0 {lab=#net6}
N 920 -0 920 80 {lab=xxx}
N -200 80 920 80 {lab=xxx}
N -200 0 -200 80 {lab=xxx}
N -110 -0 -70 -0 {lab=#net1}
N 50 0 90 0 {lab=#net2}
N 210 0 250 0 {lab=#net3}
N 370 0 410 -0 {lab=#net4}
N 540 -0 580 -0 {lab=#net5}
N 710 0 750 -0 {lab=#net6}
N 880 0 920 0 {lab=xxx}
N -160 40 -160 60 {lab=DGND}
N -160 60 830 60 {lab=DGND}
N 830 40 830 60 {lab=DGND}
N -0 40 0 60 {lab=DGND}
N 160 40 160 60 {lab=DGND}
N 320 40 320 60 {lab=DGND}
N 490 40 490 60 {lab=DGND}
N 660 40 660 60 {lab=DGND}
N -160 -60 -160 -40 {lab=DVDD}
N -160 -60 830 -60 {lab=DVDD}
N 830 -60 830 -40 {lab=DVDD}
N -0 -60 0 -40 {lab=DVDD}
N 160 -60 160 -40 {lab=DVDD}
N 320 -60 320 -40 {lab=DVDD}
N 490 -60 490 -40 {lab=DVDD}
N 660 -60 660 -40 {lab=DVDD}
N 830 -80 830 -60 {lab=DVDD}
N 830 60 830 100 {lab=DGND}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} -50 0 0 0 {name=x1}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 110 0 0 0 {name=x2}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 270 0 0 0 {name=x3}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 430 0 0 0 {name=x4}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 600 0 0 0 {name=x5}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 770 0 0 0 {name=x6}
C {/home/ee24s053/ee5311-2025/tut5/inv/cell/subcircuit/inv.sym} 940 0 0 0 {name=x7}
C {iopin.sym} 830 -80 0 0 {name=p2 lab=DVDD}
C {iopin.sym} 830 100 0 0 {name=p3 lab=DGND}
C {opin.sym} 920 0 0 0 {name=p1 lab=vout}
