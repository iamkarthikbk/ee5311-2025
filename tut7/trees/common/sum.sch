v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {verilog_code.sym} -40 0 0 0 {name=s1 string="assign S = P ^ C;"}
C {ipin.sym} -90 -20 0 0 {name=p1 lab=P}
C {ipin.sym} -90 10 0 0 {name=p2 lab=C}
C {opin.sym} 140 -10 0 0 {name=p3 lab=S}
C {noconn.sym} 140 -10 0 0 {name=l1}
C {noconn.sym} -90 -20 0 1 {name=l2}
C {noconn.sym} -90 10 0 1 {name=l3}
