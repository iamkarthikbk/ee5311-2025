v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {verilog_code.sym} -85 10 0 0 {name=s1 string="assign C = g | (p & c);"}
C {ipin.sym} -105 -15 0 0 {name=p1 lab=g}
C {ipin.sym} -105 10 0 0 {name=p2 lab=p}
C {ipin.sym} -105 35 0 0 {name=p3 lab=c}
C {opin.sym} 110 -15 0 0 {name=p4 lab=C}
C {noconn.sym} 110 -15 0 0 {name=l1}
C {noconn.sym} -105 -15 0 1 {name=l2}
C {noconn.sym} -105 10 0 1 {name=l3}
C {noconn.sym} -105 35 0 1 {name=l4}
