v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {/home/ee24s053/ee5311-2025/tut7/trees/brent-kung/adder.sym} 20 0 0 0 {name=x1}
C {lab_wire.sym} -130 -320 0 0 {name=p1  lab=b7
verilog_type=reg}
C {lab_wire.sym} -130 -300 0 0 {name=p2  lab=a13
verilog_type=reg}
C {lab_wire.sym} -130 -280 0 0 {name=p3  lab=b5
verilog_type=reg}
C {lab_wire.sym} -130 -260 0 0 {name=p4  lab=b4
verilog_type=reg}
C {lab_wire.sym} -130 -240 0 0 {name=p5  lab=a8
verilog_type=reg}
C {lab_wire.sym} -130 -220 0 0 {name=p6  lab=b13
verilog_type=reg}
C {lab_wire.sym} -130 -200 0 0 {name=p7  lab=a16
verilog_type=reg}
C {lab_wire.sym} -130 -180 0 0 {name=p8  lab=a5
verilog_type=reg}
C {lab_wire.sym} -130 -160 0 0 {name=p9  lab=b11
verilog_type=reg}
C {lab_wire.sym} -130 -140 0 0 {name=p10  lab=a7
verilog_type=reg}
C {lab_wire.sym} -130 -120 0 0 {name=p11  lab=b12
verilog_type=reg}
C {lab_wire.sym} -130 -100 0 0 {name=p12  lab=b10
verilog_type=reg}
C {lab_wire.sym} -130 -80 0 0 {name=p13  lab=a10
verilog_type=reg}
C {lab_wire.sym} -130 -60 0 0 {name=p14  lab=b9
verilog_type=reg}
C {lab_wire.sym} -130 -40 0 0 {name=p15  lab=a9
verilog_type=reg}
C {lab_wire.sym} -130 -20 0 0 {name=p16  lab=a15
verilog_type=reg}
C {lab_wire.sym} -130 0 0 0 {name=p17  lab=b16
verilog_type=reg}
C {lab_wire.sym} -130 20 0 0 {name=p18  lab=a11
verilog_type=reg}
C {lab_wire.sym} -130 40 0 0 {name=p19  lab=b14
verilog_type=reg}
C {lab_wire.sym} -130 60 0 0 {name=p20  lab=a6
verilog_type=reg}
C {lab_wire.sym} -130 80 0 0 {name=p21  lab=b6
verilog_type=reg}
C {lab_wire.sym} -130 100 0 0 {name=p22  lab=a12
verilog_type=reg}
C {lab_wire.sym} -130 120 0 0 {name=p23  lab=a14
verilog_type=reg}
C {lab_wire.sym} -130 140 0 0 {name=p24  lab=b15
verilog_type=reg}
C {lab_wire.sym} -130 160 0 0 {name=p25  lab=a4
verilog_type=reg}
C {lab_wire.sym} -130 180 0 0 {name=p26  lab=b3
verilog_type=reg}
C {lab_wire.sym} -130 200 0 0 {name=p27  lab=a3
verilog_type=reg}
C {lab_wire.sym} -130 220 0 0 {name=p28  lab=b2
verilog_type=reg}
C {lab_wire.sym} -130 240 0 0 {name=p29  lab=a2
verilog_type=reg}
C {lab_wire.sym} -130 260 0 0 {name=p30  lab=b1
verilog_type=reg}
C {lab_wire.sym} -130 280 0 0 {name=p31  lab=a1
verilog_type=reg}
C {lab_wire.sym} -130 300 0 0 {name=p32  lab=cin
verilog_type=reg}
C {lab_wire.sym} -130 320 0 0 {name=p33  lab=b8
verilog_type=reg}
C {lab_wire.sym} 170 -320 0 1 {name=p34  lab=cout
verilog_type=reg}
C {lab_wire.sym} 170 -300 0 1 {name=p35  lab=s16
verilog_type=reg}
C {lab_wire.sym} 170 -280 0 1 {name=p36  lab=s15
verilog_type=reg}
C {lab_wire.sym} 170 -260 0 1 {name=p37  lab=s13
verilog_type=reg}
C {lab_wire.sym} 170 -240 0 1 {name=p38  lab=s12
verilog_type=reg}
C {lab_wire.sym} 170 -220 0 1 {name=p39  lab=s11
verilog_type=reg}
C {lab_wire.sym} 170 -200 0 1 {name=p40  lab=s10
verilog_type=reg}
C {lab_wire.sym} 170 -180 0 1 {name=p41  lab=s9
verilog_type=reg}
C {lab_wire.sym} 170 -160 0 1 {name=p42  lab=s8
verilog_type=reg}
C {lab_wire.sym} 170 -140 0 1 {name=p43  lab=s7
verilog_type=reg}
C {lab_wire.sym} 170 -120 0 1 {name=p44  lab=s6
verilog_type=reg}
C {lab_wire.sym} 170 -100 0 1 {name=p45  lab=s5
verilog_type=reg}
C {lab_wire.sym} 170 -80 0 1 {name=p46  lab=s14
verilog_type=reg}
C {lab_wire.sym} 170 -60 0 1 {name=p47  lab=s4
verilog_type=reg}
C {lab_wire.sym} 170 -40 0 1 {name=p48  lab=s3
verilog_type=reg}
C {lab_wire.sym} 170 -20 0 1 {name=p49  lab=s2
verilog_type=reg}
C {lab_wire.sym} 170 0 0 1 {name=p50  lab=s1
verilog_type=reg}
C {noconn.sym} -130 -320 1 0 {name=l1}
C {noconn.sym} -130 -300 1 0 {name=l2}
C {noconn.sym} -130 -280 1 0 {name=l3}
C {noconn.sym} -130 -260 1 0 {name=l4}
C {noconn.sym} -130 -240 1 0 {name=l5}
C {noconn.sym} -130 -220 1 0 {name=l6}
C {noconn.sym} -130 -200 1 0 {name=l7}
C {noconn.sym} -130 -180 1 0 {name=l8}
C {noconn.sym} -130 -160 1 0 {name=l9}
C {noconn.sym} -130 -140 1 0 {name=l10}
C {noconn.sym} -130 -120 1 0 {name=l11}
C {noconn.sym} -130 -100 1 0 {name=l12}
C {noconn.sym} -130 -80 1 0 {name=l13}
C {noconn.sym} -130 -60 1 0 {name=l14}
C {noconn.sym} -130 -40 1 0 {name=l15}
C {noconn.sym} -130 -20 1 0 {name=l16}
C {noconn.sym} -130 0 1 0 {name=l17}
C {noconn.sym} -130 20 1 0 {name=l18}
C {noconn.sym} -130 40 1 0 {name=l19}
C {noconn.sym} -130 60 1 0 {name=l20}
C {noconn.sym} -130 80 1 0 {name=l21}
C {noconn.sym} -130 100 1 0 {name=l22}
C {noconn.sym} -130 120 1 0 {name=l23}
C {noconn.sym} -130 140 1 0 {name=l24}
C {noconn.sym} -130 160 1 0 {name=l25}
C {noconn.sym} -130 180 1 0 {name=l26}
C {noconn.sym} -130 200 1 0 {name=l27}
C {noconn.sym} -130 220 1 0 {name=l28}
C {noconn.sym} -130 240 1 0 {name=l29}
C {noconn.sym} -130 260 1 0 {name=l30}
C {noconn.sym} -130 280 1 0 {name=l31}
C {noconn.sym} -130 300 1 0 {name=l32}
C {noconn.sym} -130 320 1 0 {name=l33}
C {noconn.sym} 170 -320 1 0 {name=l34}
C {noconn.sym} 170 -300 1 0 {name=l35}
C {noconn.sym} 170 -280 1 0 {name=l36}
C {noconn.sym} 170 -260 1 0 {name=l37}
C {noconn.sym} 170 -240 1 0 {name=l38}
C {noconn.sym} 170 -220 1 0 {name=l39}
C {noconn.sym} 170 -200 1 0 {name=l40}
C {noconn.sym} 170 -180 1 0 {name=l41}
C {noconn.sym} 170 -160 1 0 {name=l42}
C {noconn.sym} 170 -140 1 0 {name=l43}
C {noconn.sym} 170 -120 1 0 {name=l44}
C {noconn.sym} 170 -100 1 0 {name=l45}
C {noconn.sym} 170 -80 1 0 {name=l46}
C {noconn.sym} 170 -60 1 0 {name=l47}
C {noconn.sym} 170 -40 1 0 {name=l48}
C {noconn.sym} 170 -20 1 0 {name=l49}
C {noconn.sym} 170 0 1 0 {name=l50}
C {verilog_code.sym} 250 -290 0 0 {name=s1 string="
reg [15:0] A;
reg [15:0] B;
initial begin
  $dumpfile(\\"brent-kung.vcd\\");
  $dumpvars(0, cin, a1, a2, a3, a4, a5, a6, a7, a8, a9, a10, a11, a12, a13, a14, a15, a16, b1, b2, b3, b4, b5, b6, b7, b8, b9, b10, b11, b12, b13, b14, b15, b16, cout, s1, s2, s3, s4, s5, s6, s7, s8, s9, s10, s11, s12, s13, s14, s15, s16);
end
integer x;
always begin
for (x=1; x<65536; x=x+1) begin
#10
A = x;
B = x ^ 'b1010101010101010;
a1 = A[0];
a2 = A[1];
a3 = A[2];
a4 = A[3];
a5 = A[4];
a6 = A[5];
a7 = A[6];
a8 = A[7];
a9 = A[8];
a10 = A[9];
a11 = A[10];
a12 = A[11];
a13 = A[12];
a14 = A[13];
a15 = A[14];
a16 = A[15];
b1 = B[0];
b2 = B[1];
b3 = B[2];
b4 = B[3];
b5 = B[4];
b6 = B[5];
b7 = B[6];
b8 = B[7];
b9 = B[8];
b10 = B[9];
b11 = B[10];
b12 = B[11];
b13 = B[12];
b14 = B[13];
b15 = B[14];
b16 = B[15];
cin = x[0];
end
#10
$finish;
end
"}
