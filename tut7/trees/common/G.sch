v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {verilog_code.sym} -35 5 0 0 {name=s1 string="assign G = A & B;"}
C {ipin.sym} -90 -15 0 0 {name=p1 lab=A}
C {ipin.sym} -90 10 0 0 {name=p2 lab=B}
C {opin.sym} 155 0 0 0 {name=p3 lab=G}
C {noconn.sym} 155 0 0 0 {name=l1}
C {noconn.sym} -90 -15 0 1 {name=l2}
C {noconn.sym} -90 10 0 1 {name=l3}
