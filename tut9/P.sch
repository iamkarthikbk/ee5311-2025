v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} -120 -60 0 0 {name=p1 lab=A}
C {ipin.sym} -120 -40 0 0 {name=p2 lab=B}
C {opin.sym} 50 -50 0 0 {name=p3 lab=P}
C {verilog_code.sym} -110 -40 0 0 {name=s1 string="assign P = A ^ B;"}
C {noconn.sym} 50 -50 0 0 {name=l1}
C {noconn.sym} -120 -60 0 1 {name=l2}
C {noconn.sym} -120 -40 0 1 {name=l3}
