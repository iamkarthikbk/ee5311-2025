v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {verilog_code.sym} -140 -10 0 0 {name=s1 string="assign \{cout, sum\} = a + b + cin;"}
C {ipin.sym} -160 -35 0 0 {name=p1 lab=a}
C {ipin.sym} -160 -10 0 0 {name=p2 lab=b}
C {ipin.sym} -160 15 0 0 {name=p3 lab=cin}
C {opin.sym} 150 -35 0 0 {name=p4 lab=sum}
C {opin.sym} 150 5 0 0 {name=p5 lab=cout}
C {noconn.sym} 150 -35 0 0 {name=l1}
C {noconn.sym} 150 5 0 0 {name=l2}
C {noconn.sym} -160 -35 0 0 {name=l3}
C {noconn.sym} -160 -10 0 0 {name=l4}
C {noconn.sym} -160 15 0 0 {name=l5}
