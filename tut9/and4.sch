v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {verilog_code.sym} -140 0 0 0 {name=s1 string="assign bypass = p0 & p1 & p2 & p3;"}
C {ipin.sym} -150 -30 0 0 {name=p1 lab=p0}
C {ipin.sym} -150 -10 0 0 {name=p2 lab=p1}
C {ipin.sym} -150 10 0 0 {name=p3 lab=p2}
C {ipin.sym} -150 30 0 0 {name=p4 lab=p3}
C {opin.sym} 170 0 0 0 {name=p5 lab=bypass}
C {noconn.sym} 170 0 0 0 {name=l1}
C {noconn.sym} -150 -30 0 0 {name=l2}
C {noconn.sym} -150 -10 0 0 {name=l3}
C {noconn.sym} -150 10 0 0 {name=l4}
C {noconn.sym} -150 30 0 0 {name=l5}
